* Trilkring
L_L1         2 3  1uH
C_C1         2 3  10nF
R_RL         2 3  60
V_Vdd        3 0 11V
