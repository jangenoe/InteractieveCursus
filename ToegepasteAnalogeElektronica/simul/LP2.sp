* Sallen and Key Low pass filter
R1 1 2 10k
R2 2 3 10k
XOpAmp 3 4 8 9 5 8 opamp
C1 2 5 1.6nF
C2 3 0 1.6nF
Rkx 5 4 100k
Rx 4 0 100k
Vin 1 0 AC 0.5 0 DC 0
VPOS 8 0 DC +2.5V
VNEG 9 0 DC -2.5V
